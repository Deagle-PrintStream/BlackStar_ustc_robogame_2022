# Keil uVision project blackstar_2022.uvprojx, settings and files
target blackstar_2022 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: blackstar_2022 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK-ARM
    ./: startup_stm32f103xe.s
  group core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group HAL_driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group gripper
    ../Core/Gripper/: gripper.cpp gyroscope.cpp
  group tracer
    ../Core/Tracer/: sensor.cpp tracer.cpp tracerSelector.cpp
  group patrol
    ../Core/Patrol/: chassis.cpp path.cpp plan.cpp
  group other
    ../Core/Other/: callback.cpp common.cpp counter.cpp debug.cpp initialize.cpp connectivity.c
  group motor
    ../Core/Motor/: motor.cpp pid.cpp
software components: CMSIS:CORE 4.3.0
